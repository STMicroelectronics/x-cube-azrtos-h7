<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Ux_Device_CDC_ACM_Standalone.ewp</path>
  </project>
  <batchBuild />
</workspace>
