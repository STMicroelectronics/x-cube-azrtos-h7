<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Tx_Thread_MsgQueue.ewp</path>
  </project>
  <batchBuild />
</workspace>
