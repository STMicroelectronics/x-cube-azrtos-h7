<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Nx_TCP_Echo_Client.ewp</path>
  </project>
  <batchBuild />
</workspace>
