<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Ux_Device_HID_CDC_ACM.ewp</path>
  </project>
  <batchBuild />
</workspace>
