<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Tx_Module_Manager_CM7.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\Tx_Module_CM7.ewp</path>
  </project>
  <batchBuild />
</workspace>
