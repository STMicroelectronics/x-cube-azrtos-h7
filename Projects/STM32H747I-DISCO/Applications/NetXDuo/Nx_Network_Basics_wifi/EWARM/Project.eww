<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Nx_Network_Basics_wifi.ewp</path>
  </project>
  <batchBuild />
</workspace>
