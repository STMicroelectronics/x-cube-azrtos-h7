<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Nx_Iperf_wifi.ewp</path>
  </project>
  <batchBuild />
</workspace>
