<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Fx_NoR_Write_Read_File.ewp</path>
  </project>
  <batchBuild />
</workspace>
