<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Fx_File_Edit_Standalone.ewp</path>
  </project>
  <batchBuild />
</workspace>
