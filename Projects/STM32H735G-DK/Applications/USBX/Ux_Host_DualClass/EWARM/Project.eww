<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Ux_Host_DualClass.ewp</path>
  </project>
  <batchBuild />
</workspace>
