<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Nx_UDP_Echo_Server.ewp</path>
  </project>
  <batchBuild />
</workspace>
