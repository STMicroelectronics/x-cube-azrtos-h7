<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Tx_FreeRTOS_Wrapper.ewp</path>
  </project>
  <batchBuild />
</workspace>
